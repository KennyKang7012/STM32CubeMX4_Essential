# Keil uVision project ADC_Single_Conversion.uvprojx, settings and files
target ADC_Single_Conversion (ARM-ADS)
  device: STM32F411VETx STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ADC_Single_Conversion
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_adc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_cortex.c
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
software components: CMSIS:CORE 4.1.0
